# Keil uVision project UART.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: MDR32F9Q2I milandr
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UART
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group System
    ./: startup_MDR32F9x.s system_MDR32F9x.c
  group Main
    ./: main.c read_message.c
  group Hardware
    ./: MDR32_UART.c
